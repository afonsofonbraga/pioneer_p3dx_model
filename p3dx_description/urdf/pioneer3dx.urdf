Commit message: Modifying laser position

File: p3dx_description/urdf/pioneer3dx.urdf (robot description, URDF)
Before this commit: robot pioneer3dx, 11 links, 10 joints
Joints:
- joint lms100_joint: origin xyz=0.12 0 0.26 rpy=0 0 0 -> xyz=0.15 0 0.08 rpy=0 0 0
